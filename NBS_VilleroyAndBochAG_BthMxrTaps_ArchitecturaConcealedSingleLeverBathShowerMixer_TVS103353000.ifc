Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-03-07T08:02:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Mar 07 08:02:28 2022* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{2356FBED-A983-4147-8209-4429FA1BEDB5}\ifc* Database version: 5507* Database creation date: Mon Mar 07 08:02:27 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Mar 07 08:02:28 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Mar 07 08:02:28 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowController: ArchitecturaConcealedSingleLeverBathShowerMixer_TVS103353000, NBS_VilleroyAndBochAG_BthMxrTaps_Architectura_ConcealedSingleLeverBathShowerMixer_TVS103353000:ArchitecturaConcealedSingleLeverBathShowerMixer_TVS103353000:55209
In: Level 1
Type - PredefinedType: FAUCET; Classification: Pr_40_20_87_08 (Uniclass2015); Material: NBS_VilleroyAndBochAG_Chrome
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_BathMixerTaps_ArchitecturaConcealedSingleLeverBathShowerMixer_TVS103353000; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/fyrdclue; ProductInformation: n/a; Uniclass2015Title: Bath mixer taps; Uniclass2015Code: Pr_40_20_87_08; Uniclass2015Version: Products v1.22; Version: 3
Type - NBS_Data - Approval: n/a; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; FlowRateMaximum: n/a; Form: Concealed single-lever bath/ shower mixer; IntegralAccessories: Automatic diverter; MaterialsBody: Brass; MaterialsFinishAndColour: Chrome-plated; Recyclability: n/a; RecycledContent: n/a; Standards: n/a; WaterSupplyTemperatureMaximum: n/a
Type - IFC - IfcExportAs: IfcValveType; IfcExportType: FAUCET
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_08:Bath mixer taps; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: n/a; Material: n/a; ModelNumber: n/a; ModelReference: Architectura Concealed Single Lever Bath Shower Mixer TVS103353000; Name: BathMixerTaps_ArchitecturaConcealedSingleLeverBathShowerMixer_TVS103353000_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; Barcode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
